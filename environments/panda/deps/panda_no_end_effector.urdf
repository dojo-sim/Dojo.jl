Commit message: panda box push

File: environments/panda/deps/panda_no_end_effector.urdf (robot description, URDF)
Before this commit: robot panda, 9 links, 8 joints
Links:
- removed link link7
Joints:
- removed joint joint7
