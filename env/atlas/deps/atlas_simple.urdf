Commit message: add colors to atlas

File: env/atlas/deps/atlas_simple.urdf (robot description, URDF)
Before this commit: robot atlas, 31 links, 30 joints
Links:
- link head: geometry visual mesh filename=env/atlas/deps/mesh/head.obj
